Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-03-06T12:54:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 06 12:54:22 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\dea5cb0b-6e84-46ff-b5e1-509412b8da1d\163ab248-ca9e-4b14-9d93-f8d5f8072e4f\ifc * Database version: 5507 * Database creation date: Thu Mar 06 12:54:21 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 06 12:54:22 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 06 12:54:22 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328399
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 1132, Lâmpada_PAR30_1130_1131_1132_Nordecor_IFC:1132:328399
In: Nível 1
Type - Material: Metal - Ferro, Plástico - Branco - Fosco, Plástico - Acrilico - Translucido, LED
Type - Cotas - Altura: 88.7 mm; Diâmetro: 95 mm
Type - Dados - Data de atualização: 25/02/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Lâmpada de LED PAR30 9W 4000K 40º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Itajaí-SC / Brasil; Modelo: 316881; Nome do tipo: 1132; Número OmniClass: 23.80.70.00; Observação: Não dimerizável; Tipo de imagem: Imagem raster: PAR30.jpg; Título OmniClass: Lighting; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/lampada-par30-sof-9w-2-700k-3-000k-4-000k/; Vida útil: 25.000h
Type - Elétrico - Comentários de voltagem: 100-240VAC; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Lâmpada: 0 W
Type - Engenharia elétrica - Corrente elétrica: 0 A; Fator de potência - Lâmpada: 0.7; Frequência: 0 Hz; Voltagem - Lâmpada: 0 V
Type - Estrutural - Peso: 0.09 Kg
Type - Fotométricos - Ângulo de abertura: 40 deg; Fluxo luminoso: 860 lm; IRC: 95; Potência: 9 W; Temperatura de cor: 4000 K
Type - Materiais e acabamentos - PAR30: Alumínio e polímero sintético
Type - Outros - Categoria: Luminárias; 2700K - 40º: no; 3000K - 40º: no; 4000K - 40º: yes; Branco: yes; Nome da família: Lâmpada_PAR30_1130_1131_1132_Nordecor_IFC
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes; F. Luminosa: yes
Cotas - Área: 0.0199179 m2; Volume: 0.000204478 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Lâmpada_PAR30_1130_1131_1132_Nordecor_IFC: 1132; Família e tipo: Lâmpada_PAR30_1130_1131_1132_Nordecor_IFC: 1132; ID de tipo: Lâmpada_PAR30_1130_1131_1132_Nordecor_IFC: 1132; Tipo: Lâmpada_PAR30_1130_1131_1132_Nordecor_IFC: 1132
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
